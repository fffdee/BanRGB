# Keil uVision project air001_template.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: AIR001Dev Generic
  pack: Keil.AIR001_DFP.1.1.2
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: air001template +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=3 wLevel=3
  c define: AIR001_DEV
  c include: .\AIR001xx_HAL_Driver\Inc;.\User;D:\Embedded Engineer\Keil5\Packs\Keil\AIR001_DFP\1.1.0\Device\Include;.\User\uart;.\User\ws2812b;.\User\HSV2RGB;.\User\SPI;.\User\flash;.\User\DEF
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group HAL
    ./AIR001xx_HAL_Driver/Src/: air001xx_hal.c air001xx_hal_cortex.c air001xx_hal_crc.c air001xx_hal_exti.c air001xx_hal_gpio.c air001xx_hal_rcc.c air001xx_hal_flash.c air001xx_hal_pwr.c air001xx_hal_uart.c air001xx_hal_dma.c air001xx_hal_spi.c
    ./AIR001xx_HAL_Driver/Inc/: air001xx_hal.h air001xx_hal_cortex.h air001xx_hal_crc.h air001xx_hal_exti.h air001xx_hal_gpio.h air001xx_hal_rcc.h air001xx_hal_flash.h air001xx_hal_pwr.h air001xx_hal_uart.h air001xx_hal_uart_ex.h
  group user
    ./User/: air001xx_hal_conf.h air001xx_it.c air001xx_it.h main.c
  group hardware
    ./User/uart/: uart.c
    ./User/SPI/: spi.c
    ./User/HSV2RGB/: hsvrgb.c
    ./User/ws2812b/: ws2812b.c
    ./User/DEF/: def_conf.c
software components: CMSIS:CORE 5.6.0, Device:Startup 0.0.1
